FILESEXTRAPATHS_prepend_amd-snowyowl := "${THISDIR}/${PN}:"
SRC_URI += "file://xorg.conf"
