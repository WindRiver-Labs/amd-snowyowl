#
# Copyright (C) 2020 Wind River Systems, Inc.
#

require linux-yocto-amd-snowyowl.inc

KBRANCH_amd-snowyowl  = "v5.2/standard/amd-x86"
