require linux-yocto-amd-snowyowl.inc

KBRANCH_amd-snowyowl  = "v5.2/standard/preempt-rt/amd-x86"

LINUX_VERSION_amd-snowyowl ?= "5.2.x"
